# Keil uVision project Project.uvprojx, settings and files
target GD32F130_150_OLED_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\Firmware\CMSIS\GD\GD32F1x0\Include;..\Utilities;..\Firmware\CMSIS\GD\GD32F1x0\Source\ARM;..\Firmware\GD32F1x0_standard_peripheral\Include;..\User\include;..\Firmware\CMSIS;C:\Users\freer\AppData\Local\Arm\Packs\ARM\CMSIS\4.5.0\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../User/: gd32f1x0_it.c main.c systick.c led.c keys.c printf_debug.c oled_iic.c fonts.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Peripherals
    ../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dbg.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_syscfg.c gd32f1x0_misc.c gd32f1x0_usart.c gd32f1x0_rcu.c gd32f1x0_i2c.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Utilities
    ../Utilities/: gd32f1x0r_eval.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c queue.c list.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../: readme.txt
